# Keil uVision project Project.uvprojx, settings and files
target CWtest (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CW32F030C8 WHXY
  pack: WHXY.CW32F030_DFP.1.0.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Libraries\inc;..\Libraries\src;..\Startup;..\User\inc;..\User\src;..\DOC;..\MBCI
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Startup
    ../Startup/: startup_cw32f030.s
  group Libraries
    ../Libraries/inc/: base_types.h cw32f030.h system_cw32f030.h cw32f030_adc.h cw32f030_atim.h cw32f030_awt.h cw32f030_btim.h cw32f030_crc.h cw32f030_debug.h cw32f030_digitalsign.h cw32f030_dma.h cw32f030_flash.h cw32f030_gpio.h cw32f030_gtim.h cw32f030_i2c.h cw32f030_iwdt.h cw32f030_lvd.h cw32f030_pwr.h cw32f030_ram.h cw32f030_rcc.h cw32f030_rtc.h cw32f030_spi.h cw32f030_systick.h cw32f030_uart.h cw32f030_vc.h cw32f030_wwdt.h
    ../Libraries/src/: system_cw32f030.c cw32f030_adc.c cw32f030_atim.c cw32f030_awt.c cw32f030_btim.c cw32f030_crc.c cw32f030_debug.c cw32f030_digitalsign.c cw32f030_dma.c cw32f030_flash.c cw32f030_gpio.c cw32f030_gtim.c cw32f030_i2c.c cw32f030_iwdt.c cw32f030_lvd.c cw32f030_pwr.c cw32f030_ram.c cw32f030_rcc.c cw32f030_rtc.c cw32f030_spi.c cw32f030_systick.c cw32f030_uart.c cw32f030_vc.c cw32f030_wwdt.c
  group MBCI
    ../MBCI/: mbci_assert.h mbci_button.h mbci_chassis.h mbci_encoder.h mbci_gpio.c mbci_gpio.h mbci_imu.h mbci_ir.h mbci_motor.h
  group User
    ../User/src/: main.c interrupts_cw32f030.c
    ../User/inc/: main.h interrupts_cw32f030.h
software components: CMSIS:CORE 5.5.0
